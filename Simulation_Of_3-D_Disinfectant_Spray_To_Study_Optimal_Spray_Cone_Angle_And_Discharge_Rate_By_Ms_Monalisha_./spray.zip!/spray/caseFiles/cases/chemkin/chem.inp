ELEMENTS
 H   O    C   N  
END
SPECIE
H2O O2 N2 CO2 
END

